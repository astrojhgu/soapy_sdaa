options:
  parameters:
    generate_options: qt_gui
    id: zmq_send
    output_language: python
    title: waterfall
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: freq_range*1e6
  states: {}
- name: freq_range
  id: variable_qtgui_range
  parameters:
    label: freq
    start: '30'
    step: '1'
    stop: '210'
    value: '120'
  states: {}
- name: gain
  id: variable
  parameters:
    value: gain_range
  states: {}
- name: gain_range
  id: variable_qtgui_range
  parameters:
    label: gain
    start: '-100'
    step: '1'
    stop: '0'
    value: '-20'
  states: {}
- name: nch
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 240e6
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: nch
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: nch
    x_start: freq/1e6-samp_rate/1e6/2
    x_step: samp_rate/1e6/nch
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: float
    vlen: nch
  states: {}

connections:
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [zeromq_pull_source_0, '0', blocks_nlog10_ff_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
