options:
  parameters:
    generate_options: qt_gui
    id: sdaa
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: freq_range*1e6
  states: {}
- name: freq_range
  id: variable_qtgui_range
  parameters:
    label: freq
    start: '30'
    step: '1'
    stop: '210'
    value: '120'
  states: {}
- name: nch
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 120e6
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters:
    vlen: nch
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '100'
    max_iter: '10'
    scale: '1'
    type: complex
    vlen: nch
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: nch
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '57.29577951308232'
    type: float
    vlen: nch
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: nch
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nch
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nch
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nch
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nch)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: nch
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nch)
  states: {}
- name: qtgui_vector_sink_f_1
  id: qtgui_vector_sink_f
  parameters:
    vlen: nch
    x_start: '0'
    x_step: '1.0'
    ymax: '90'
    ymin: '-90'
  states: {}
- name: qtgui_vector_sink_f_1_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.2'
    vlen: nch
    x_start: '0'
    x_step: '1.0'
    ymax: '90'
    ymin: '-90'
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    antenna0: EXT
    center_freq0: freq
    dc_removal0: 'False'
    driver: sdaa,cfg=cfg0.yaml,ip=192.168.5.231
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_custom_source_0_0
  id: soapy_custom_source
  parameters:
    antenna0: EXT
    center_freq0: freq
    dc_removal0: 'False'
    driver: sdaa,cfg=cfg0.yaml,ip=192.168.5.227
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_complex_to_magphase_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_multiply_const_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_magphase_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', qtgui_vector_sink_f_1, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_1_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [soapy_custom_source_0, '0', blocks_stream_to_vector_0, '0']
- [soapy_custom_source_0_0, '0', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
