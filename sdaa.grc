options:
  parameters:
    generate_options: qt_gui
    id: sdaa
    output_language: python
    thread_safe_setters: '1'
    title: Correlator
  states: {}

blocks:
- name: corr_samp_rate
  id: variable
  parameters:
    value: '100'
  states: {}
- name: freq
  id: variable
  parameters:
    value: freq_range*1e6
  states: {}
- name: freq_range
  id: variable_qtgui_range
  parameters:
    label: freq
    start: '30'
    step: '1'
    stop: '210'
    value: '120'
  states: {}
- name: gain
  id: variable
  parameters:
    value: gain_range
  states: {}
- name: gain_range
  id: variable_qtgui_range
  parameters:
    label: gain
    start: '-100'
    step: '1'
    stop: '0'
    value: '-20'
  states: {}
- name: naverage
  id: variable
  parameters:
    value: '100'
  states: {}
- name: nch
  id: variable
  parameters:
    value: '16384'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 240e6
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nch
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nch
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters:
    maxoutbuf: '65536'
    minoutbuf: '65536'
    vlen: nch
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters:
    vlen: nch
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: naverage
    type: complex
    vlen: nch
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: naverage
    type: float
    vlen: nch
  states: {}
- name: blocks_integrate_xx_0_0_0
  id: blocks_integrate_xx
  parameters:
    decim: naverage
    type: float
    vlen: nch
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    maxoutbuf: '65536'
    minoutbuf: '65536'
    vlen: nch
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '57.29577951308232'
    maxoutbuf: '65536'
    minoutbuf: '65536'
    type: float
    vlen: nch
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    maxoutbuf: '65536'
    minoutbuf: '65536'
    n: '10'
    vlen: nch
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    maxoutbuf: '65536'
    minoutbuf: '65536'
    n: '10'
    vlen: nch
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    maxoutbuf: '65536'
    minoutbuf: '65536'
    n: '10'
    vlen: nch
  states: {}
- name: blocks_stream_to_vector_decimator_0
  id: blocks_stream_to_vector_decimator
  parameters:
    sample_rate: samp_rate
    type: complex
    vec_rate: corr_samp_rate
    vlen: nch
  states: {}
- name: blocks_stream_to_vector_decimator_0_0
  id: blocks_stream_to_vector_decimator
  parameters:
    sample_rate: samp_rate
    type: complex
    vec_rate: corr_samp_rate
    vlen: nch
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nch
    forward: 'True'
    maxoutbuf: '65536'
    minoutbuf: '65536'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nch)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: nch
    forward: 'True'
    maxoutbuf: '65536'
    minoutbuf: '65536'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nch)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: nch
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nch)
  states: {}
- name: qtgui_vector_sink_f_1
  id: qtgui_vector_sink_f
  parameters:
    legend: 'False'
    maxoutbuf: '65536'
    minoutbuf: '65536'
    vlen: nch
    x_axis_label: '"freq"'
    x_start: freq/1e6-samp_rate/1e6/2
    x_step: samp_rate/1e6/nch
    x_units: '"MHz"'
    y_axis_label: '"phase"'
    y_units: '"deg"'
    ymax: '90'
    ymin: '-90'
  states: {}
- name: qtgui_vector_sink_f_1_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.2'
    label1: xx
    label2: yy
    label3: xy
    maxoutbuf: '65536'
    minoutbuf: '65536'
    nconnections: '3'
    vlen: nch
    x_axis_label: '"freq"'
    x_start: freq/1e6-samp_rate/1e6/2
    x_step: samp_rate/1e6/nch
    x_units: '"MHz"'
    y_axis_label: '"ampl"'
    y_units: '"dB"'
    ymax: '90'
    ymin: '-90'
  states: {}
- name: qtgui_vector_sink_f_1_1
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    legend: 'False'
    maxoutbuf: '65536'
    minoutbuf: '65536'
    vlen: nch
    x_axis_label: '"delay"'
    x_start: '-nch/2'
    x_step: '1'
    x_units: '"pt"'
    y_axis_label: real
    y_units: '"rel"'
    ymax: '90'
    ymin: '-90'
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    antenna0: EXT
    center_freq0: freq
    dc_removal0: 'False'
    driver: sdaa,cfg=cfg0.yaml,ip=192.168.5.231
    gain0: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_custom_source_0_0
  id: soapy_custom_source
  parameters:
    antenna0: EXT
    center_freq0: freq
    dc_removal0: 'False'
    driver: sdaa,cfg=cfg0.yaml,ip=192.168.5.227
    gain0: gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_integrate_xx_0_0_0, '0']
- [blocks_complex_to_magphase_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_multiply_const_xx_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_vector_sink_f_1_1, '0']
- [blocks_integrate_xx_0, '0', blocks_complex_to_magphase_0, '0']
- [blocks_integrate_xx_0, '0', fft_vxx_1, '0']
- [blocks_integrate_xx_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_integrate_xx_0_0_0, '0', blocks_nlog10_ff_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_integrate_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', qtgui_vector_sink_f_1, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_1_0, '2']
- [blocks_nlog10_ff_0_0, '0', qtgui_vector_sink_f_1_0, '0']
- [blocks_nlog10_ff_0_0_0, '0', qtgui_vector_sink_f_1_0, '1']
- [blocks_stream_to_vector_decimator_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_decimator_0_0, '0', fft_vxx_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_1, '0', blocks_complex_to_real_0, '0']
- [soapy_custom_source_0, '0', blocks_stream_to_vector_decimator_0, '0']
- [soapy_custom_source_0_0, '0', blocks_stream_to_vector_decimator_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
