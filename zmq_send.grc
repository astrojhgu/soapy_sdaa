options:
  parameters:
    generate_options: qt_gui
    id: zmq_send
    output_language: python
    title: waterfall
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: freq_range*1e6
  states: {}
- name: freq_range
  id: variable_qtgui_range
  parameters:
    label: freq
    start: '30'
    step: '1'
    stop: '210'
    value: '120'
  states: {}
- name: gain
  id: variable
  parameters:
    value: gain_range
  states: {}
- name: gain_range
  id: variable_qtgui_range
  parameters:
    label: gain
    start: '-100'
    step: '1'
    stop: '0'
    value: '-20'
  states: {}
- name: nch
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 240e6
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nch
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '100'
    type: float
    vlen: nch
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nch
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nch
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(nch)
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    antenna0: EXT
    center_freq0: freq
    dc_removal0: 'False'
    driver: sdaa,cfg=cfg0.yaml,ip=192.168.5.231
    gain0: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: float
    vlen: nch
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_integrate_xx_0, '0', zeromq_push_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [soapy_custom_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
